options:
  parameters:
    author: szu-iot
    generate_options: no_gui
    id: NoCCABasicNode
    output_language: python
    title: NoCCABasicNode
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: LoRaNoCCA_NoCCANode_0
  id: LoRaNoCCA_NoCCANode
  parameters:
    NodeID: '1'
  states: {}
- name: RC_MAC_PHY_Sender_0
  id: RC_MAC_PHY_Sender
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("hello world,my name is node 1!")
    period: '1000'
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '1000'
    msg: pmt.intern("TEST")
  states: {state: disabled}
- name: rc_mac_phy_receiver_0
  id: rc_mac_phy_receiver
  parameters:
    nodesf: '7'
  states: {bus_source: true}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: freq
    dev_addr: '"serial=3241A02"'
    dev_args: '""'
    gain0: '90'
    len_tag_name: frame_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bw
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_addr: '"serial=3241A02"'
    dev_args: '""'
    gain0: '90'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [LoRaNoCCA_NoCCANode_0, outputData, RC_MAC_PHY_Sender_0, in]
- [RC_MAC_PHY_Sender_0, '0', uhd_usrp_sink_0, '0']
- [blocks_message_strobe_0, strobe, LoRaNoCCA_NoCCANode_0, InputData]
- [blocks_message_strobe_random_0, strobe, LoRaNoCCA_NoCCANode_0, InputData]
- [rc_mac_phy_receiver_0, Msgout, LoRaNoCCA_NoCCANode_0, InputRTS]
- [uhd_usrp_source_0, '0', LoRaNoCCA_NoCCANode_0, '0']
- [uhd_usrp_source_0, '0', rc_mac_phy_receiver_0, '0']

metadata:
  file_format: 1
